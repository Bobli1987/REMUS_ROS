Commit message: Create a new class in task_manager.cpp

File: src/ship_los/urdf/ship.urdf (robot description, URDF)
Before this commit: robot Ship, 2 links, 1 joints
Links:
- link Ship: geometry visual box size=1.13 .25 .15
